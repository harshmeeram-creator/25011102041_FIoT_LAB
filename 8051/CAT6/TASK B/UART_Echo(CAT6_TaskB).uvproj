# Keil uVision project UART_Echo(CAT6_TaskB).uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: UART_Echo(CAT6_TaskB) +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../../../../../../Desktop/25011102042_FIoT_LAB/8051/CAT6/TASK B/: cat6_taskB_uart_receive_echo.c
