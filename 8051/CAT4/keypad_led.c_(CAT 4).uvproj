# Keil uVision project keypad_led.c_(CAT 4).uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: keypad_led.c_(CAT 4)
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../../../../../../Desktop/25011102042_FIoT_LAB/8051/CAT4/: cat4_keypad_led.c
