# Keil uVision project CAT7_Task7C_Keypad_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: CAT7_Task7C_Keypad_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../../../../../../Desktop/25011102042_FIoT_LAB/8051/CAT7/TASK C/: cat7_task7C_keypad_lcd.c
