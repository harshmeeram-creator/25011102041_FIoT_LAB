# Keil uVision project LCD_(CAT7_Task A).uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: LCD_(CAT7_Task A) +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../../../../../../Desktop/25011102042_FIoT_LAB/8051/CAT7/TASK A/: cat7_task7A_lcd_display.c
